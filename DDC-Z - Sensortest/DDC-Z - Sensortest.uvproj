# Keil uVision project DDC-Z - Sensortest.uvproj, settings and files
target Target 1 (MCS-51)
  device: N79E855 Nuvoton
  cpu: IRAM(0x00-0xFF) IROM(0x000-0x3FFF) XRAM(0x00-0xFF) CLOCK(24000000) MODP2
  output: DDC-Z - Sensortest +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library
  group Library
    ../Library/: AD.c Battery.c communication.c Delay.c operation.c Other.c pwm.c Timer.c UART.c voice.c ISP_DataFlash.c ElecMotor.c Schedular.c
  group DDC-Z
    ./: Main.c
